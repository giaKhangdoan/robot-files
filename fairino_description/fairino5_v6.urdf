Commit message: doi lai xyz J6 trong urdf

File: fairino_description/fairino5_v6.urdf (robot description, URDF)
Before this commit: robot fairino5_v6_robot, 7 links, 6 joints
Joints:
- joint j6: axis 0 0 0 -> 0 0 1
